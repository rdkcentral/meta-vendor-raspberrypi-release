# Reference: from vendor dev layer
# Enable legacy sys/fs/cgroup/memory support for DAC

CMDLINE:append = " cgroup_enable=memory cgroup_memory=1"

