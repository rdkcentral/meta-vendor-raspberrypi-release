PV = "2.4.0"
SRCREV_rdk-apparmor-profiles = "d44bb823cbf4bb4fcd2460f0810ef18131869183"
