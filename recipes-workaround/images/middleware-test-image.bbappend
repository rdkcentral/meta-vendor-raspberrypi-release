IMAGE_INSTALL:remove = " packagegroup-application-layer"
