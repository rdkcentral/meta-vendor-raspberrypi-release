# TODO: RDKVREFPLT-4456: remove when PKG ARCK is part of upstream MW
PACKAGE_ARCH = "${MIDDLEWARE_ARCH}"
