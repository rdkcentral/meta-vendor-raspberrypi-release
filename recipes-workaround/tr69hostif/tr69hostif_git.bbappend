# To do: Remove when RDK-54145 is resolved
PACKAGECONFIG:remove = "sdcard"
