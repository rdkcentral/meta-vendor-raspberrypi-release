RPROVIDES:${PN} = "virtual/default-font"
RPROVIDES = "virtual/default-font"
